Commit message: renamed kinetic to melodic

File: racecar_ws/src/launch/robot.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 3 joints
Joints:
- joint base_to_laser: origin xyz=0.028575 0.08255 0.1508625 rpy=0 0 0 -> xyz=0.028575 0.08255 0.1508625 rpy=0 0 3.14159
